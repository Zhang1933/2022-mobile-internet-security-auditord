## hello-kernel/src/Kconfig
```kconfig
config HELLO_KERNEL
    tristate "Test kernel driver"
    help
        This is an Kernel Driver Test
        if unsure ,delete it ,just for fun
```
